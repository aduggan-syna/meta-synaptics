ALTERNATIVE_PRIORITY[resolv-conf] = "20"
