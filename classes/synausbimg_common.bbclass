#/*******************************************************************************
#*
#*             Copyright 2020, Beechwoods Software, Inc.
#*
#*******************************************************************************/

SYNAIMG_DEPLOY_SUBDIR ?= "SYNAUSBIMG"

