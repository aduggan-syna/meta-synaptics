require syna-swupdate-image.inc
