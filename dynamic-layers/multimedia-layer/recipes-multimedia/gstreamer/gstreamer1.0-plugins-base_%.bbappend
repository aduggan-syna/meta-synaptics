PACKAGECONFIG:append = " opus"

