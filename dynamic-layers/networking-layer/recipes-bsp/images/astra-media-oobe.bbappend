IMAGE_INSTALL:append = " \
    bridge-utils \
    "
