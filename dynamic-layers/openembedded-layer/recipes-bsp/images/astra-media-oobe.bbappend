require astra-media-openembedded-common.inc
