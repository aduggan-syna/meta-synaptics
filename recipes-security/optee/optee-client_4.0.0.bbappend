FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
EXTRA_OECMAKE += " \
    -DRPMB_EMU=OFF \
"

