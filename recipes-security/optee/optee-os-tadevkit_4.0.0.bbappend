require optee-syna.inc
