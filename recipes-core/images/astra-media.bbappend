# Add libgpiod and gpiod command-line tools into astra-media image

IMAGE_INSTALL:append = " libgpiod libgpiod-tools"

